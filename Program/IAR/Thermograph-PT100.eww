<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Thermograph-PT100.ewp</path>
    </project>
    <batchBuild />
</workspace>
