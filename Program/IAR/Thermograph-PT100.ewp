# IAR project Thermograph-PT100.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; USE_STM8L1526_EVAL
  ICCSTM8.CCIncludePath2: E:\Project\PT100温度测量仪\Thermograph-PT100\Program\IAR\Header
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Thermograph-PT100.srec
  ILINK.IlinkOutputFile: Thermograph-PT100.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    App/: Seg.c TM7705.c
  group Bsp
    Bsp/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_tim2.c
  group Header
    Header/: Main.h Seg.h stm8l151k4.h stm8l15x.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_gpio.h stm8l15x_itc.h stm8l15x_tim2.h
  group User
    User/: Main.c
